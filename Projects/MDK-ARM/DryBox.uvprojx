# Keil uVision project DryBox.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32E230F8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: CMOS_GD_TD_rev_V65 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=objects\@L.bin !L
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\GD32E23x_Firmware_Library\CMSIS\GD\GD32E23x\Include;..\..\Utilities;..\..\GD32E23x_Firmware_Library\GD32E23x_standard_peripheral\Include;.\RTE\_GD32E230F_START;..\..\Projects;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xcc00
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group GD32E230_START
    ../../Utilities/: gd32e230f_start.c
  group CMSIS
    ../../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group GD32E23x_Peripherals
    ../../GD32E23x_Firmware_Library/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group User
    ../: main.c gd32e23x_it.c systick.c
    ../../User/: gpio.c gpio.h usart.c usart.h user.c user.h adc.c adc.h timer.h timer.c flash.c flash.h led_config.c led_config.h ds18b20.c ds18b20.h
  group Doc
    ../../: readme.txt
